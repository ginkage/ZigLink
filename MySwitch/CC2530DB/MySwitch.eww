<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MySwitch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>MySwitch</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>MySwitch</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>MySwitch</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>MySwitch</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


